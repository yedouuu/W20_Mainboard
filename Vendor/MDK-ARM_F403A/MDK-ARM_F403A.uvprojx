# Keil uVision project MDK-ARM_F403A.uvprojx, settings and files
target MDK-ARM_F403A (6240000::V6.24::ARMCLANG)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MDK-ARM_F403A
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,LV_LVGL_H_INCLUDE_SIMPLE
  c include: ..\EIDE;Platform\Firmware\CMSIS;Platform\Firmware\Device\Include;Platform\Firmware\Device\StdPeriph_Driver\inc;Platform;Platform\Core;Platform\BSP;..\..\USER\HAL;..\..\USER\Middleware\EasyLogger\inc;..\..\USER\Middleware\Unity;..\..\USER\Middleware\RTT;..\..\USER\Middleware\LVGL\example\porting;..\..\USER\Middleware\LVGL\src;..\..\USER\Middleware\LVGL\demos;..\..\USER\Middleware\LVGL;..\..\USER\Middleware;..\..\USER\Utils;..\..\USER\Tests;..\..\USER\Application;..\..\USER;..\..\Framework;..\..\Framework\DeviceManager;..\..\USER\Middleware\LVGL\demos\widgets;..\EIDE\.cmsis\include;RTE\_W20_Mainboard;..\..\USER\Middleware\LVGL\demos\benchmark;..\..\USER\Middleware\LVGL\demos\music;..\..\USER\Middleware\LVGL\demos\music\assets;..\..\USER\Application\Pages;..\..\USER\Middleware\CmBacktrace\cm_backtrace;..\..\USER\Middleware\CmBacktrace\cm_backtrace\Languages\zh-CN;..\..\USER\Middleware\CmBacktrace\cm_backtrace\Languages\en-US;..\..\Framework\PageManager;..\..\USER\Utils\lv_ext;..\..\USER\Utils\Logger;..\..\USER\Middleware\SFUD\inc;..\..\USER\Middleware\FreeRTOS\include;..\..\USER\Middleware\FreeRTOS;..\..\USER\Middleware\FreeRTOS\portable
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: Objects\MDK-ARM_F403A.sct
  group Framework/PageManager
    ../../Framework/PageManager/: PageBase.cpp PageFactory.h PageManager.h PM_Base.cpp PM_Drag.cpp PM_Log.h PM_Router.cpp PM_State.cpp PM_Anim.cpp
  group Framework/DeviceManager
    ../../Framework/DeviceManager/: device_manager.c
  group Platform/Firmware/StdPeriph_Driver
    Platform/Firmware/Device/StdPeriph_Driver/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group Platform/Firmware/Device
    Platform/Firmware/Device/Source/: system_at32f403a_407.c startup_at32f403avgt7.s startup_at32f403avgt7_ext_ram.s extend_SRAM.c
  group Platform/Core
    Platform/Core/: at32f403a_407_clock.c at32f403a_407_int.c systick.c mcu_core.c mcu_type.h gpio.c uart.c exti.c timer.c pwm.c adc.c i2c.c i2c_application.c spi.c sw_spi.c
  group Platform/BSP
    Platform/BSP/: bsp_led.c bsp_key.c bsp_ir.c bsp_lcd.c bsp_touch.c bsp_sflash.c bsp_tm1638.c bsp_config.c bsp_config.h bsp_motor.c bsp_encoder.c
  group HAL
    ../../USER/HAL/: drv_ir_wrapper.c drv_led_wrapper.c drv_lcd_wrapper.c drv_touch_wrapper.c drv_wrapper.h drv_tick_wrapper.c drv_wrapper.c drv_keypad_wrapper.c drv_motor_wrapper.c drv_encoder_wrapper.c
  group HAL/Adapter
    ../../USER/HAL/Adapter/: drv_ir_adapter.c drv_touch_adapter.c drv_lcd_adapter.c drv_tick_adapter.c drv_keypad_adapter.c drv_motor_adapter.c drv_encoder_adapter.c
  group Middleware/FreeRTOS
    ../../USER/Middleware/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c FreeRTOSConfig.h
  group Middleware/FreeRTOS/portable
    ../../USER/Middleware/FreeRTOS/portable/: port.c portmacro.h
    ../../USER/Middleware/FreeRTOS/portable/MemMang/: heap_4.c
  group Middleware/SFUD/scr
    ../../USER/Middleware/SFUD/src/: sfud.c sfud_sfdp.c
    ../../USER/Middleware/SFUD/inc/: sfud_cfg.h sfud_def.h sfud_flash_def.h
  group Middleware/SFUD/porting
    ../../USER/Middleware/SFUD/port/: sfud_port.c
  group Middleware/CmBacktrace
    ../../USER/Middleware/CmBacktrace/cm_backtrace/: cm_backtrace.c cmb_cfg.h cmb_def.h
    ../../USER/Middleware/CmBacktrace/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group Middleware/LVGL
    ../../USER/Middleware/LVGL/: lv_conf.h lv_version.h lvgl.h
  group Middleware/LVGL/demos
    ../../USER/Middleware/LVGL/demos/widgets/: lv_demo_widgets.c lv_demo_widgets_analytics.c lv_demo_widgets_components.c lv_demo_widgets_profile.c lv_demo_widgets_shop.c
    ../../USER/Middleware/LVGL/demos/: lv_demos.c
    ../../USER/Middleware/LVGL/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
    ../../USER/Middleware/LVGL/demos/benchmark/: lv_demo_benchmark.c lv_demo_benchmark.h
    ../../USER/Middleware/LVGL/demos/benchmark/assets/: img_benchmark_avatar.c img_benchmark_lvgl_logo_argb.c img_benchmark_lvgl_logo_rgb.c lv_font_benchmark_montserrat_12_aligned.c lv_font_benchmark_montserrat_14_aligned.c lv_font_benchmark_montserrat_16_aligned.c lv_font_benchmark_montserrat_18_aligned.c lv_font_benchmark_montserrat_20_aligned.c lv_font_benchmark_montserrat_24_aligned.c lv_font_benchmark_montserrat_26_aligned.c
    ../../USER/Middleware/LVGL/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../../USER/Middleware/LVGL/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
  group Middleware/LVGL/scr
    ../../USER/Middleware/LVGL/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../../USER/Middleware/LVGL/src/display/: lv_display.c
    ../../USER/Middleware/LVGL/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../../USER/Middleware/LVGL/src/draw/convert/: lv_draw_buf_convert.c
    ../../USER/Middleware/LVGL/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../USER/Middleware/LVGL/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../USER/Middleware/LVGL/src/layouts/: lv_layout.c
    ../../USER/Middleware/LVGL/src/layouts/flex/: lv_flex.c
    ../../USER/Middleware/LVGL/src/layouts/grid/: lv_grid.c
    ../../USER/Middleware/LVGL/src/stdlib/: lv_mem.c
    ../../USER/Middleware/LVGL/src/themes/: lv_theme.c
    ../../USER/Middleware/LVGL/src/themes/default/: lv_theme_default.c
    ../../USER/Middleware/LVGL/src/themes/mono/: lv_theme_mono.c
    ../../USER/Middleware/LVGL/src/themes/simple/: lv_theme_simple.c
    ../../USER/Middleware/LVGL/src/tick/: lv_tick.c
    ../../USER/Middleware/LVGL/src/widgets/3dtexture/: lv_3dtexture.c
    ../../USER/Middleware/LVGL/src/widgets/animimage/: lv_animimage.c
    ../../USER/Middleware/LVGL/src/widgets/arc/: lv_arc.c
    ../../USER/Middleware/LVGL/src/widgets/arclabel/: lv_arclabel.c
    ../../USER/Middleware/LVGL/src/widgets/bar/: lv_bar.c
    ../../USER/Middleware/LVGL/src/widgets/button/: lv_button.c
    ../../USER/Middleware/LVGL/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../USER/Middleware/LVGL/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../USER/Middleware/LVGL/src/widgets/canvas/: lv_canvas.c
    ../../USER/Middleware/LVGL/src/widgets/chart/: lv_chart.c
    ../../USER/Middleware/LVGL/src/widgets/checkbox/: lv_checkbox.c
    ../../USER/Middleware/LVGL/src/widgets/dropdown/: lv_dropdown.c
    ../../USER/Middleware/LVGL/src/widgets/image/: lv_image.c
    ../../USER/Middleware/LVGL/src/widgets/imagebutton/: lv_imagebutton.c
    ../../USER/Middleware/LVGL/src/widgets/keyboard/: lv_keyboard.c
    ../../USER/Middleware/LVGL/src/widgets/label/: lv_label.c
    ../../USER/Middleware/LVGL/src/widgets/led/: lv_led.c
    ../../USER/Middleware/LVGL/src/widgets/line/: lv_line.c
    ../../USER/Middleware/LVGL/src/widgets/list/: lv_list.c
    ../../USER/Middleware/LVGL/src/widgets/lottie/: lv_lottie.c
    ../../USER/Middleware/LVGL/src/widgets/menu/: lv_menu.c
    ../../USER/Middleware/LVGL/src/widgets/msgbox/: lv_msgbox.c
    ../../USER/Middleware/LVGL/src/widgets/objx_templ/: lv_objx_templ.c
    ../../USER/Middleware/LVGL/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../../USER/Middleware/LVGL/src/widgets/roller/: lv_roller.c
    ../../USER/Middleware/LVGL/src/widgets/scale/: lv_scale.c
    ../../USER/Middleware/LVGL/src/widgets/slider/: lv_slider.c
    ../../USER/Middleware/LVGL/src/widgets/span/: lv_span.c
    ../../USER/Middleware/LVGL/src/widgets/spinbox/: lv_spinbox.c
    ../../USER/Middleware/LVGL/src/widgets/spinner/: lv_spinner.c
    ../../USER/Middleware/LVGL/src/widgets/switch/: lv_switch.c
    ../../USER/Middleware/LVGL/src/widgets/table/: lv_table.c
    ../../USER/Middleware/LVGL/src/widgets/tabview/: lv_tabview.c
    ../../USER/Middleware/LVGL/src/widgets/textarea/: lv_textarea.c
    ../../USER/Middleware/LVGL/src/widgets/tileview/: lv_tileview.c
    ../../USER/Middleware/LVGL/src/widgets/win/: lv_win.c
    ../../USER/Middleware/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../../USER/Middleware/LVGL/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../USER/Middleware/LVGL/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../../USER/Middleware/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../USER/Middleware/LVGL/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../USER/Middleware/LVGL/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../USER/Middleware/LVGL/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../USER/Middleware/LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../USER/Middleware/LVGL/src/: lv_init.c
    ../../USER/Middleware/LVGL/src/others/observer/: lv_observer.c
    ../../USER/Middleware/LVGL/src/others/file_explorer/: lv_file_explorer.c
    ../../USER/Middleware/LVGL/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../../USER/Middleware/LVGL/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../USER/Middleware/LVGL/src/others/gridnav/: lv_gridnav.c
    ../../USER/Middleware/LVGL/src/others/ime/: lv_ime_pinyin.c
    ../../USER/Middleware/LVGL/src/others/imgfont/: lv_imgfont.c
    ../../USER/Middleware/LVGL/src/others/monkey/: lv_monkey.c
    ../../USER/Middleware/LVGL/src/others/snapshot/: lv_snapshot.c
    ../../USER/Middleware/LVGL/src/others/sysmon/: lv_sysmon.c
    ../../USER/Middleware/LVGL/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../../USER/Middleware/LVGL/src/others/translation/: lv_translation.c
    ../../USER/Middleware/LVGL/src/osal/: lv_os.c lv_os_none.c lv_freertos.c lv_cmsis_rtos2.c
    ../../USER/Middleware/LVGL/src/libs/bin_decoder/: lv_bin_decoder.c
    ../../USER/Middleware/LVGL/src/libs/bmp/: lv_bmp.c
    ../../USER/Middleware/LVGL/src/libs/barcode/: code128.c lv_barcode.c
    ../../USER/Middleware/LVGL/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../../USER/Middleware/LVGL/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../USER/Middleware/LVGL/src/libs/libpng/: lv_libpng.c
  group Middleware/LVGL/porting
    ../../USER/Middleware/LVGL/example/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group Middleware/RTT
    ../../USER/Middleware/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Conf.h
  group Middleware/Unity
    ../../USER/Middleware/Unity/: unity.c
  group Middleware/EasyLogger
    ../../USER/Middleware/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../../USER/Middleware/EasyLogger/port/: elog_port.c
    ../../USER/Middleware/EasyLogger/inc/: elog_cfg.h
  group Tests
    ../../USER/Tests/: unit_test.c fault_test.c test_sfud.c test_bsp_sflash.c
  group Utils/new
    ../../USER/Utils/new/: new.cpp
  group Utils/Logger
    ../../USER/Utils/Logger/: Logger.c
  group Utils/lv_ext
    ../../USER/Utils/lv_ext/: lv_anim_timeline_wrapper.c lv_obj_ext_func.cpp
  group Application
    ../../USER/Application/: App.cpp AppTasks.cpp
  group Application/System
    ../../USER/Application/System/: key_scan.c sample.c
  group Application/Resources
    ../../USER/Application/Resources/: BankosaMainPage.c LightMode.c
  group Application/Pages
    ../../USER/Application/Pages/: Page.h AppPageFactory.cpp
  group Application/Pages/__Template
    ../../USER/Application/Pages/__Template/: __Template.cpp __TemplateModel.cpp __TemplateView.cpp
  group Application/Pages/Startup
    ../../USER/Application/Pages/Startup/: Startup.cpp StartupModel.cpp StartupView.cpp
  group Application/Pages/UserSettings
    ../../USER/Application/Pages/UserSettings/: UserSettings.cpp UserSettingsModel.cpp UserSettingsView.cpp
  group Application/Pages/MainPage
    ../../USER/Application/Pages/MainPage/: MainPage.cpp MainPageModel.cpp MainPageView.cpp
  group Application/Services
    ../../USER/Application/Services/: pocket_detect.c machine_ctrl.c
  group Application/Common
    ../../USER/Application/Common/: common.h comm_macro.h binary.h errno.h context.c
  group USER
    ../../USER/: main.cpp
